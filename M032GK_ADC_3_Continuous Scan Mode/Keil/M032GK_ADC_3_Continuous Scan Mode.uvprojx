# Keil uVision project M032GK_ADC_3_Continuous Scan Mode.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: M032KG8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\M031BSP\Library\CMSIS\Core\Include;..\..\M031BSP\Library\Device\Nuvoton\M031\Include;..\..\M031BSP\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../M031BSP/Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../M031BSP/Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../M031BSP/Library/StdDriver/src/: clk.c gpio.c retarget.c timer.c uart.c adc.c sys.c
    ../../M031BSP/Library/StdDriver/inc/: uart.h
  group User
    ../: main.c clk_config.c clk_config.h pin_config.c pin_config.h pin_labels.h
